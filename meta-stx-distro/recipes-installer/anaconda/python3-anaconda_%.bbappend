FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://0001-dnfpayload-add-support-for-the-groups-from-comps.xml.patch \
"
