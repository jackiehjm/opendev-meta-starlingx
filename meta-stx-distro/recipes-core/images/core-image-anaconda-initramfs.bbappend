IMAGE_INSTALL_append = " \
    gptfdisk \
    "
