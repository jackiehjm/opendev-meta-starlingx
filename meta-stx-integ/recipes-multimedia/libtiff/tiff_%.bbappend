PREMIRRORS_prepend = "\n \
    http://download.osgeo.org/libtiff/ https://ftp.osuosl.org/pub/blfs/conglomeration/tiff/ \n \
    "
