RDEPENDS_${PN}_class-native = ""
BBCLASSEXTEND = "native"
