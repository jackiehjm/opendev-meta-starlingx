DESCRIPTION = "The source recipe for StarlingX Upstream Packages repo"

inherit stx-source

STX_REPO = "upstream"
