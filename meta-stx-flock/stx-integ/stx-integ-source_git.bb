DESCRIPTION = "The source recipe for StarlingX Integration repo"

inherit stx-source

STX_REPO = "integ"
