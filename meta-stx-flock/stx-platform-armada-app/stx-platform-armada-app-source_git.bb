DESCRIPTION = "The source recipe for StarlingX platform-armada-app"

inherit stx-source

STX_REPO = "platform-armada-app"

BRANCH = "r/stx.5.0"
SRCREV = "42b97c591a38167623f6dccb35f3b3ff67fd78db"
